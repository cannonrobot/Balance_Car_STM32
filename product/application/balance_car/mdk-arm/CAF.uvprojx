# Keil uVision project CAF.uvprojx, settings and files
target Cannon_V1 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAF
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ENABLE_SPI_FIX,BLUENRG_MS,RTC_LSE,CANNON_V1,SENSOR_FIFO,NO_PRINTF
  c misc: --C99 --gnu -W#177
  c include: ..\..\..\..\system\bsp\cannon_v1;..\..\..\..\system\bsp\nucleo;..\..\..\..\system\drivers\lps25h;..\..\..\..\system\drivers\lps25hb;..\..\..\..\system\drivers\lsm303agr;..\..\..\..\system\drivers\lsm6ds3;..\..\..\..\system\drivers\stm32f4xx_hal_driver\inc;..\..\..\..\system\cmiss\device\st\inc;..\..\..\..\system\cmiss\include;..\..\..\..\system\juma\inc;..\..\..\..\system\drivers\common;..\..\..\..\system\drivers\bluenrg\inc;..\..\..\..\system\drivers\bluenrg\bluenrg_ms;..\..\..\..\system\drivers\hts221;..\..\sensor_tag_fifo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group product/application
    ../: app.c outputdata.c function.c ffconf.h FreeRTOSConfig.h imu_sensor_fusion_9-axis.c control.c audio_application.c waveplayer.c
    ../../../../system/juma/src/: imu_sensor_fusion.c
  group system/juma
    ../../../../system/juma/src/: main.c bluenrg_sdk_api.c dispatch.c stm32f401_lp_mode.c bluenrg_interface.c stm32xx_it.c clock.c cube_hal_f4.c imu_sensor.c juma_sensor.c
  group system/drivers
    ../../../../system/drivers/hts221/: hts221.c
    ../../../../system/drivers/lps25h/: lps25h.c
    ../../../../system/drivers/lps25hb/: lps25hb.c
    ../../../../system/drivers/lsm6ds3/: lsm6ds3.c
    ../../../../system/drivers/lsm303agr/: lsm303agr.c LSM303AGR_ACC_driver.c LSM303AGR_MAG_driver.c
    ../../../../system/drivers/stm32f4xx_hal_driver/src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c
    ../../../../system/drivers/bluenrg/src/: osal.c hci.c gp_timer.c bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_itf_template.c bluenrg_l2cap_aci.c list.c
    ../../../../system/drivers/bluenrg/bluenrg_ms/: stm32_bluenrg_ble.c
    ../../../../system/drivers/sta350bw/: sta350bw.c
  group system/bsp
    ../../../../system/bsp/nucleo/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_imu_6axes.c x_nucleo_iks01a1_pressure.c x_nucleo_cca01m1.c x_nucleo_cca01m1_audio_f4.c
    ../../../../system/bsp/cannon_v1/: stm32f4xx_cannon_v1.c
    ../../../../system/bsp/cannon_v2/: stm32f4xx_cannon_v2.c stm32f4xx_hal_msp.c stm32469i_discovery_sd.c
  group system/cmiss
    ../../../../system/cmiss/device/st/src/: startup_stm32f401xe.s system_stm32f4xx.c
  group system/Fatfs
    ../../../../system/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../system/FatFs/src/drivers/: sd_diskio.c
  group system/FreeRTOS
    ../../../../system/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../system/FreeRTOS/Source/: croutine.c queue.c tasks.c timers.c OS_list.c
    ../../../../system/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../system/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group system/BiquadCalculator
    ../../../../system/BiquadCalculator/: BiquadCalculator.c BiquadPresets.c
target Cannon_V2 (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: as above
  output: CAF_V2
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ENABLE_SPI_FIX,BLUENRG_MS,RTC_LSE,CANNON_V2,SENSOR_FIFO,NO_PRINTF,I2C_DMA_MODE
  c misc: --C99 --gnu
  c include: ..\..\..\..\system\drivers\hts221;..\..\..\..\system\drivers\lps25h;..\..\..\..\system\drivers\lps25hb;..\..\..\..\system\drivers\lsm303agr;..\..\..\..\system\drivers\lsm6ds3;..\..\..\..\system\drivers\stm32f4xx_hal_driver\inc;..\..\..\..\system\drivers\common;..\..\..\..\system\drivers\bluenrg\inc;..\..\..\..\system\drivers\bluenrg\bluenrg_ms;..\..\..\..\system\bsp\nucleo;..\..\..\..\system\bsp\cannon_v2;..\..\..\..\system\juma\inc;..\..\..\..\system\cmiss\device\st\inc;..\..\..\..\system\cmiss\include;..\..\balance_car;..\..\..\..\system\FatFs\src;..\..\..\..\system\FatFs\src\drivers;..\..\..\..\system\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\system\FreeRTOS\Source\include;..\..\..\..\system\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\system\BiquadCalculator;..\..\..\..\system\drivers\sta350bw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 4.1.0
